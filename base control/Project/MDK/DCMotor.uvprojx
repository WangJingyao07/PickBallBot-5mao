# Keil uVision project DCMotor.uvprojx, settings and files
target DCMotor (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DCMotor +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\App;..\..\App\Demo\Include;..\..\Board\Include;..\..\Chip\CMSIS;..\..\Chip\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../App/: main.c stm32f10x_it.c
  group Board
    ../../Board/Source/: BSP_Delay.c BSP_DCMotor.c BSP_DebugUART.c DataScope_DP.C BSP_Timer.c encoder.c BSP_Key.c BSP_Control.c BSP_BlueTooth.c BSP_ADConverter.c gy85.c
    ./: DMA.c
  group CMSIS
    ../../Chip/CMSIS/startup/: startup_stm32f10x_hd.s
    ../../Chip/CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriph_Driver
    ../../Chip/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Doc
    ../../Document/: Readme.txt
